v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
T {AC coupled LNA
This is part of a frontend for dry EEG electrode data acquisition

Constraints
- } -190 -50 0 0 0.4 0.4 {}
C {/foss/designs/ttsky-bci-low-noise-amp/xschem/ota.sym} 160 150 0 0 {name=x1}
