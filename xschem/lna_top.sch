v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {AC coupled LNA
This is part of a frontend for dry EEG electrode data acquisition

Constraints
- } -190 -50 0 0 0.4 0.4 {}
